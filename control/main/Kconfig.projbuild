## control/main/Kconfig.projbuild
```kconfig
menu "Nixie WiFi Options"

    config SSID
        string "SSID"
    config PSK
        string "Passkey"

endmenu
```
